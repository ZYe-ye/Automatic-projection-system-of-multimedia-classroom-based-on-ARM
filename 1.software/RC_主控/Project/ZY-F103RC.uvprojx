# Keil uVision project ZY-F103RC.uvprojx, settings and files
target ZY-F103RC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZY-F103ZE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\User;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\TB6600;..\HARDWARE\Limit_switch;..\HARDWARE\KEY;..\HARDWARE\nrf;..\HARDWARE\usart3;..\HARDWARE\LD3320;..\HARDWARE\SYN6288;..\HARDWARE\control;..\HARDWARE\mechanical_arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/TB6600/: Driver_X.c Driver_Y.c Driver_Z.c
    ../HARDWARE/Limit_switch/: Limit_switch.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/nrf/: bsp_spi_nrf.c
    ../HARDWARE/LD3320/: LDChip.c Reg_RW.c
    ../HARDWARE/SYN6288/: syn6288.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/mechanical_arm/: mechanical_arm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Doc
    ../Doc/: readme.txt
